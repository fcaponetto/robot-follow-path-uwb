<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$/master_i2c.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>